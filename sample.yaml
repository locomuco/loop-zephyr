## sample.yaml
```yaml
sample:
  description: loop client zephyr application
    application
  name: loop client
```
